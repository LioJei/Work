# Keil uVision project template.uvprojx, settings and files
target Target 1 (6100001::V6.10.1::.\ARMCLANG)
  device: GD32F103VE GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.3.0
  cpu: CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32F10X_HD, __FPU_PRESENT
  c include: ..\CMSIS;..\Library\Include;..\User;..\Module
  library: MicroLIB
  group CMSIS
    ../CMSIS/: system_gd32f10x.c
  group Startup
    ../Startup/: startup_gd32f10x_md.s
  group Library
    ../Library/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group User
    ../User/: gd32f10x_it.c main.c systick.c gd32f10x_eval.c
